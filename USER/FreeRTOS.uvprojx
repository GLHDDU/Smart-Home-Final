# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\HMAC\inc;..\HMAC\scr;..\TASK;..\HARDWARE\dht11;..\HARDWARE\LED;..\HARDWARE\mqtt;..\HARDWARE\time2;..\HARDWARE\time3;..\HARDWARE\time4;..\HARDWARE\uart2;..\HARDWARE\usart1;..\HARDWARE\wifi;..\HARDWARE\key;..\HMAC\scr;..\HARDWARE\44key;..\HARDWARE\44key;..\HARDWARE\memu;..\HARDWARE\LED;..\HARDWARE\lcd;..\HARDWARE\ft5206;..\HARDWARE\gt9147;..\HARDWARE\ott2001a;..\HARDWARE\iic;..\HARDWARE\touch;..\HARDWARE\time8;..\HARDWARE\uart4;..\HARDWARE\time7;..\HARDWARE\uart5;..\TASK;..\HARDWARE\step_motor
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/dht11/: dht11.c
    ../HARDWARE/mqtt/: mqtt.c
    ../HARDWARE/time2/: timer2.c
    ../HARDWARE/time3/: timer3.c
    ../HARDWARE/time4/: timer4.c
    ../HARDWARE/uart2/: usart2.c
    ../HARDWARE/usart1/: usart1.c
    ../HARDWARE/wifi/: wifi.c
    ../HARDWARE/key/: key.c
    ../HARDWARE/lcd/: lcd.c
    ../HARDWARE/gt9147/: gt9147.c
    ../HARDWARE/iic/: ctiic.c
    ../HARDWARE/touch/: touch.c
    ../HARDWARE/time8/: time8.c
    ../HARDWARE/uart4/: uart4.c
    ../HARDWARE/time7/: time7.c
    ../HARDWARE/uart5/: uart5.c
    ../HARDWARE/step_motor/: step_motor.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_wwdg.c stm32f10x_spi.c stm32f10x_sdio.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_iwdg.c stm32f10x_i2c.c stm32f10x_fsmc.c stm32f10x_flash.c stm32f10x_dma.c stm32f10x_dbgmcu.c stm32f10x_dac.c stm32f10x_crc.c stm32f10x_cec.c stm32f10x_can.c stm32f10x_bkp.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group README
    ../: README.TXT
  group TASK
    ../TASK/: MQTT_TASK.c Lcd_TASK.c Actuator_TASK.c Vioce_TASK.c
  group HMAC
    ../HMAC/scr/: utils_hmac.c utils_md5.c utils_sha1.c
